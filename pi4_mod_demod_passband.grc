options:
  parameters:
    author: ivan
    generate_options: qt_gui
    id: pi4_baseband
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: '120000'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    soft_dec_lut: '''auto'''
    type: dqpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: frq_diff
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,3,1,1
    label: Честотно отклонение
    start: '0'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {}
- name: noise_level
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Ниво на шума
    start: '0'
    step: '0.1'
    stop: '20'
    value: '0'
  states: {}
- name: phase_diff
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Фазова разлика
    start: '0'
    step: '0.1'
    stop: 3.14/2
    value: '0'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '576000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_level
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '128'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Local Oscillator TX
    freq: carrier_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '2'
    comment: Local Oscillator RX
    freq: '-carrier_freq+frq_diff'
    offset: '0'
    phase: phase_diff
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    comment: |-
      Hello World
      1. 	H	   72 - 	01 00 10 00
      2. 	e 	101 - 	01 10 01 01
      3. 	 l 	108 - 	01 10 11 00
      4. 	 l  	108 - 	01 10 11 00
      5. 	o 	111 - 	01 10 11 11
      6. 	           32 - 	00 10 00 00
      7.	W      87 -  	01 01 01 11
      8.	 o  	111 - 	01 10 11 11
      9.	 r 	114 - 	01 11 00 10
      10.	 l 	108 - 	01 10 11 00
      11.  d 	100 - 	01 10 01 00
      12.   ! 	   33 - 	00 10 00 01
      13. LF	   10 - 	00 00 10 10
    file: /home/ivan/Projects/0.5.DigiComm_General/Pi4_DQPSK/DQPSKmodem-main/HelloWorld
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '10'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_0_2
  id: blocks_vector_source_x
  parameters:
    comment: |-
      68 -  	ASCII "D" - 	01 00 01 00
      102-	ASCII "f" -	01 10 01 10
    repeat: 'True'
    type: byte
    vector: (68,102)
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,0,0,0,1,0,0,0,0)
  states: {state: disabled}
- name: blocks_vector_source_x_0_2_2
  id: blocks_vector_source_x
  parameters:
    comment: |-
      72   	ASCII "H" - 	01 00 10 00
      101	ASCII "e" -	01 10 01 01
    repeat: 'True'
    type: byte
    vector: (72,101,108,108,111,32,87,111)
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: |-
      Defines Gray encoded QPSK symbols:
      00		 +pi/4
      01		+3pi/4
      10		-pi/4
      11		-3pi/4
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (1/cmath.sqrt(2) + (1/cmath.sqrt(2))*1j, -1/cmath.sqrt(2) + (1/cmath.sqrt(2))*1j, 1/cmath.sqrt(2) - (1/cmath.sqrt(2))*1j, -1/cmath.sqrt(2) - (1/cmath.sqrt(2))*1j)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: |-
      Output index of symbol point
      from collection of all possible
      constellation points.
    constellation: constel
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n#pi/4 dqpsk modulator / created by Ivan Penchev Ivanov aka IP_Ivanov\nimport numpy as np\nfrom gnuradio import gr\nimport cmath\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='pi/4 DiffEncoder',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        #print(\"\\nMembers and methods:\\n{}\\n\".format(dir(self))) #show all member functions of this block\n        #self.set_min_noutput_items(256)\n        self.example_param = example_param\n        self.set_output_multiple(256)\n        #self.set_history(2)\n        self.last_output_item = 1 # sets initial previous output item \n        #self.LUT_phase_trans = [complex(0.70711,0.70711), complex(-0.70711,0.70711), complex(0.70711,-0.70711), complex(-0.70711,-0.70711)]\n\n    def work(self, input_items, output_items):\n        inlen = len(input_items[0])\n        #print(inlen)\n        #print(input_items[0])\n        #output_items[0][:] = input_items[0][1:len(input_items[0])] * self.example_param\n        #print(\"input_items[0]={} self.example_param={}\".format(input_items[0], self.example_param))\n        \n        i = 0\n        output_items[0][i] = self.last_output_item*input_items[0][i]\n        i=i+1\n        while i < (inlen):\n            #print(\"output_items[0][i-1]\",output_items[0][i-1])\n            #print(\"input_items[0][i]\",input_items[0][i])\n            output_items[0][i] = output_items[0][i-1] * input_items[0][i]\n            #output_items[0][i] = complex(round(output_items[0][i].real,15),round(output_items[0][i].imag,15)) \n            #print(\"output_items[0][i]\",output_items[0][i])\n            i = i + 1\n            #print(\"item0={} item1={}\".format(item0, item1))\n            self.last_output_item = output_items[0][i-1]\n        #print(i)\n        #print(self.last_output_item)\n        return len(output_items[0])\n\n"
    example_param: '1.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='DumpOut_inConsole',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #inlen = len(input_items[0])
              #print("from block 2:",inlen)
              output_items[0][:] = input_items[0] * self.example_param
              print(output_items[0][:])
              #print(bytearray([int(i) for i in output_items[0][:]]).decode('ascii'))
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    test_mode: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np, cmath
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,3,1,1
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: samp_per_sym
    size: '128'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 6,0,2,2
    label1: g(f)
    label2: y(f)
    name: '"g(f), y(f)"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 3,0,1,1
    name: '"BER"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,1,2
    marker1: '0'
    marker2: '0'
    marker3: '2'
    marker4: '2'
    name: '"S(n) and Sr(n)"'
    nconnections: '2'
    size: '32'
    srate: samp_rate
    stemplot: 'True'
    type: complex
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,0,1,2
    marker1: '0'
    marker2: '2'
    name: '"Sent anf received text "Hello World!" ASCII format"'
    nconnections: '2'
    size: '13'
    srate: samp_rate
    stemplot: 'True'
    type: float
    ymax: '127'
    ymin: '0'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: Pulse Shaping Filter TX
    gain: samp_per_sym
    interp: samp_per_sym
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: excess_bw
    comment: |-
      Pulse Shaping Filter RX
      used as a matched filter
    decim: samp_per_sym
    gain: '1'
    ntaps: 10*samp_per_sym+1
    samp_rate: samp_rate
    sym_rate: samp_rate/samp_per_sym
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: passband_rx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: passband_tx
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: after_pi/4_DiffEncoTX
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: before_pi/4_DiffEncoRX
  states: {}
- name: virtual_sink_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: g_f
  states: {}
- name: virtual_sink_0_0_0_2
  id: virtual_sink
  parameters:
    stream_id: y_f
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Packed_TX
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Packed_RX
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: passband_rx
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: passband_tx
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: after_pi/4_DiffEncoTX
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: before_pi/4_DiffEncoRX
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: g_f
  states: {}
- name: virtual_source_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: y_f
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Packed_TX
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Packed_TX
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Packed_RX
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Packed_RX
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_random_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [analog_random_source_x_0, '0', virtual_sink_1, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_1, '1']
- [blocks_complex_to_real_0, '0', virtual_sink_0_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_file_source_0, '0', virtual_sink_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0_0_0_2, '0']
- [blocks_multiply_xx_0_0, '0', root_raised_cosine_filter_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_skiphead_0_0, '0', digital_diff_phasor_cc_0, '0']
- [blocks_skiphead_0_0, '0', virtual_sink_0_0_0_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', virtual_sink_2, '0']
- [blocks_vector_source_x_0_2, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_0_2, '0', virtual_sink_1, '0']
- [blocks_vector_source_x_0_2_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_0_2_0, '0', virtual_sink_1, '0']
- [blocks_vector_source_x_0_2_1, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_0_2_1, '0', virtual_sink_1, '0']
- [blocks_vector_source_x_0_2_2, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_vector_source_x_0_2_2, '0', virtual_sink_1, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', epy_block_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0, '0']
- [digital_diff_phasor_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [epy_block_0, '0', root_raised_cosine_filter_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0, '0']
- [epy_block_1, '0', blocks_null_sink_0, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', virtual_sink_0_0_0_1, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_skiphead_0_0, '0']
- [virtual_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_0_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [virtual_source_0_0_0_1, '0', qtgui_freq_sink_x_1, '0']
- [virtual_source_0_0_0_2, '0', qtgui_freq_sink_x_1, '1']
- [virtual_source_1, '0', fec_ber_bf_0, '0']
- [virtual_source_1_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_2, '0', fec_ber_bf_0, '1']
- [virtual_source_2_0, '0', blocks_char_to_float_0_0_0, '0']

metadata:
  file_format: 1
